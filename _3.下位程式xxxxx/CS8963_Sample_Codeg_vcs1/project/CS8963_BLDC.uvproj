# Keil uVision project CS8963_BLDC.uvproj, settings and files
target Target 1 (MCS-51)
  device: DR80390 Digital Core Design
  cpu: IRAM(0-0xFF) CLOCK(50000000) MOD_CONT MODDP2
  output: CS8963_BLDC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\CS8963_Libraries\inc
  group Source Group 1
    ../src/: CS8963_BLDC.c
