http://www.aspphp.online/bianchen/cyuyan/gycyy/201701/82587.html

//用Visual C＃編寫屏幕保護程序

日期：2017/1/12 10:52:11      編輯：關於C語言
Visual C#是微軟公司推出的新一代程序開發語言，是微軟.Net框架中的一個重要組成部分。屏幕保護程序是以scr為擴展名的標准Windows可執行程序。屏幕保護程序不僅可以延長顯示器的使用壽命，還可以保護私人信息。本文向大家介紹一個.Net平台上用C#編寫的一個動態文本及圖形的屏幕保護程序。

　　一、具體實現步驟：

　　（1）在Visual Studio.Net下新建一個C＃的Windows應用程序工程，不妨命名為screen_saver。

　　（2）現在我們來設計程序的主界面：

　　先將窗體的Name屬性設置為screen、Text屬性設置為空，BackColor屬性設置為Black、Size屬性設置為(800, 600)、 ControlBox、MaximizeBox、MinimizeBox、ShowInTaskbar屬性設置均為false、FormBorderStyle屬性設置為None。再往窗體上添加Label控件、PictureBox控件、Timer控件各一個。將Label控件的Name設置為Word、Text屬性設置為空；將PictureBox控件的Name設置為picture1、Image設置為一個預知圖片；將Timer控件的Name設置為timerSaver、Enabled 屬性設為true、Interval屬性設為5。

　　（3）現在我們開始編寫完整程序代碼部分：

　

//導入使用到的名稱空間

using System;

using System.Drawing;

using System.Collections;

using System.ComponentModel;

using System.Windows.Forms;

using System.Data;

file://

　　　namespace screen_saver

　　　{

///

/// Form1 的摘要說明。

///

public class screen : System.Windows.Forms.Form

{

　file://加入私有成員變量

　private System.ComponentModel.IContainer components;

　private int iSpeed = 2;

　private string str="福建南紡股份公司計算機中心";

　file://定義文本字體及大小

　private System.Drawing.Font TextStringFont = new System.Drawing.Font ("宋體”, 10,System.Drawing.FontStyle.Bold);

　private Color TextStringcolor =System.Drawing.Color.Yellow; file://文本字體顏色

　private int iDistance;

　private int ixStart= 0;

　private int iyStart= 0;

　private int speed;

　private int x1,y1;

　int width1,height1;

　private System.Windows.Forms.Timer timerSaver;　 file://計時器控件

　private System.Windows.Forms.PictureBox picture1; file://圖形控件

　private System.Windows.Forms.Label Word; file://文本顯示控件

///

/// 必需的設計器變量。

///



　public screen()

　{

　file://

　// Windows 窗體設計器支持所必需的

　file://

　　InitializeComponent();

　　Word.Font=TextStringFont;

　　Word.ForeColor=TextStringcolor;

　　System.Windows.Forms.Cursor.Hide(); file://隱藏光標

　　file://

　　// TODO: 在 InitializeComponent 調用後添加任何構造函數代碼

　　file://

　}

　 ///

　/// 清理所有正在使用的資源。

　///

　protected override void Dispose( bool disposing )

　{

　　if( disposing )

　　{

　　　if (components != null)

　　　{

　　　　components.Dispose();

　　　}

　　}

　　base.Dispose( disposing );

　}

　#region Windows Form Designer generated code

　///

　/// 設計器支持所需的方法 - 不要使用代碼編輯器修改

　/// 此方法的內容。

　///

　private void InitializeComponent() file://初始化程序中使用到的組件

　{

　　this.components = new System.ComponentModel.Container();

　　System.Resources.ResourceManager resources = new 　　system.Resources.ResourceManger(typeof(screen));　　　 　　

　　this.Word = new System.Windows.Forms.Label();

　　this.timerSaver = new System.Windows.Forms.Timer(this.components);

　　this.picture1 = new System.Windows.Forms.PictureBox();

　　this.SuspendLayout();

　　//

　　// 設置文本顯示控件(Word)屬性

　　this.Word.ForeColor = System.Drawing.Color.Yellow;

　　this.Word.Location = new System.Drawing.Point(624, 8);

　　this.word.Name = "Word";

　　this.Word.Size = new System.Drawing.Size(168, 16);

　　this.Word.TabIndex = 0;

　　this.Word.Visible = false;

　　//

　　// 設置計時器控件(timerSaver)屬性

　　this.timerSaver.Enabled = true;

　　this.timerSaver.Interval = 5;

　　this.timerSaver.Tick += new System.EventHandler(this.timerSaver_Tick);

　　//

　　// 設置圖片控件(picture1)屬性

　　this.picture1.Image = ((System.Drawing.Bitmap)(resources.GetObject("picture1.Image")));

　　this.picture1.Location = new System.Drawing.Point(800, 600);

　　this.picture1.Name = "picture1";

　　this.picture1.Size = new System.Drawing.Size(304, 224);

　　this.picture1.SizeMode = System.Windows.Forms.PictureBoxSizeMode.StretchImage;

　　this.picture1.TabIndex = 1;

　　this.picture1.TabStop = false;

　　//

　　// 設置窗體(screen)屬性

　　this.AutoScaleBaseSize = new System.Drawing.Size(6, 14);

　　this.BackColor = System.Drawing.Color.Black;

　　this.ClIEntSize = new System.Drawing.Size(800, 600);

　　this.ControlBox = false;

　　this.Controls.AddRange(new System.Windows.Forms.Control[] {this.picture1,this.Word});

　　this.FormBorderStyle = System.Windows.Forms.FormBorderStyle.None;

　　this.KeyPrevIEw = true;

　　this.MaximizeBox = false;

　　this.MinimizeBox = false;

　　this.Name = "screen";

　　this.ShowInTaskbar = false;

　　this.StartPosition = System.Windows.Forms.FormStartPosition.Manual;

　　this.WindowState = System.Windows.Forms.FormWindowstate.Maximized;

　　file://鍵盤按下響應事件

　　this.KeyDown += new System.Windows.Forms.KeyEventHandler(this.screen_KeyDown);

　　　　　　　　　　　　file://鼠標按下響應事件
　
　　this.MouseDown += new System.Windows.Forms.MouseEventHandler(this.screen_MouseDown);

　　file://窗體啟動調用事件

　　this.Load += new System.EventHandler(this.Form1_Load);

　　　　　　　　　　　　file://鼠標移動響應事件

　　this.MouseMove += new System.Windows.Forms.MouseEventHandler(this.screen_MouseMove);

　　this.ResumeLayout(false);

　}

　#endregion

　///

　/// 應用程序的主入口點。

　///

　[STAThread]

　static void Main(string[] args)

　{

　　if(args.Length==1)

　　　if(args[0].Substring(0,2).Equals("/c"))

　　　{

　　　　MessageBox.Show("沒有設置項功能","C# Screen Saver");

　　　　Application.Exit();

　　　}

　　　else if(args[0]=="/s")

　　　Application.Run(new screen());

　　else if(args[0]=="/a")

　　{

　　　MessageBox.Show("沒有口令功能","C# Screen saver");

　　　Application.Exit();

　　}

　　else

　　Application.Run(new screen());

　}



　private void Form1_Load(object sender, System.EventArgs e)

　{

　　speed=0;

　　System.Drawing.Rectangle ssWorkArea=System.Windows.Forms.Screen.GetWorkingArea(this);
　　file://屏幕顯示區域

　　width1=ssWorkArea.Width; file://屏幕寬度

　　height1=ssWorkArea.Height; file://屏幕高度

　}


　private void timerSaver_Tick(object sender, System.EventArgs e) file://計時器響應事件

　{

　　Word.Visible=true;

　　Word.Text=str;

　　word.Height=Word.Font.Height; file://設置文本的高度

　　word.Width=word.Text.Length*(int)Word.Font.Size*2; file://設置文本的寬度

　　PlayScreenSaver();

　}

　private void PlayScreenSaver() file://自定義函數

　{

　　file://下面設置文本顯示框的位置坐標

　　word.Location =new System.Drawing.Point(width1-iDistance,Word.Location.Y);

　　Word.Visible=true; file://設置為可見

　　iDistance+=iSpeed;

　　if(word.Location.X<=-(Word.Width))

　　{

　　　iDistance=0;

　　　if(Word.Location.Y==0)

　　　　word.Location=new System.Drawing.Point(Word.Location.X,height1/2);

　　　else if(Word.Location.Y==height1/2)

　　　　word.Location=new System.Drawing.Point(word.Location.X,height1-Word.Height);

　　　else

　　　　word.Location=new System.Drawing.Point(Word.Location.X,0);

　　}

　　file://下面是計算圖片框移動坐標

　　speed++;

　　if(speed<=2*height1)

　　{

　　　x1=System.Math.Abs(width1-speed);

　　　y1=System.Math.Abs(height1-speed);

　　}

　　else if(speed>2*height1 && speed<=2*width1)

　　{

　　　x1=System.Math.Abs(width1-speed);

　　　y1=System.Math.Abs(height1-(speed-speed/height1*height1));

　　}

　　else if(speed>2*width1 &&speed<=3*height1)

　　{

　　　x1=System.Math.Abs(width1-(speed-speed/width1*width1));

　　　y1=System.Math.Abs(height1-(speed-speed/height1*height1));

　　}

　　else if(speed>3*height1 && speed<4*height1)

　　{

　　　x1=System.Math.Abs(width1-(speed-speed/width1*width1));

　　　y1=System.Math.Abs(speed-speed/height1*height1);

　　}

　　else if(speed>=4*height1 && speed<5*height1)

　　{

　　　x1=System.Math.Abs(speed-speed/width1*width1);

　　　y1=System.Math.Abs(height1-(speed-speed/height1*height1));

　　}

　　else if(speed>=5*height1 && speed<4*width1)

　　{

　　　x1=System.Math.Abs(speed-speed/width1*width1);

　　　y1=System.Math.Abs(speed-speed/height1*height1);

　　}

　　else if(speed>=4*width1 && speed<6*height1)

　　{

　　　x1=System.Math.Abs(width1-(speed-speed/width1*width1));

　　　y1=System.Math.Abs(speed-speed/height1*height1);

　　}

　　else if(speed>=6*height1 && speed<5*width1)

　　{

　　　x1=System.Math.Abs(width1-(speed-speed/width1*width1));

　　　y1=System.Math.Abs(height1-(speed-speed/height1*height1));

　　}

　　else if(speed>=5*width1 && speed<7*height1)

　　{

　　　x1=System.Math.Abs(speed-speed/width1*width1);

　　　y1=System.Math.Abs(height1-(speed-speed/height1*height1));

　　}

　　else if(speed>=7*height1 && speed<6*width1)

　　{

　　　x1=System.Math.Abs(speed-speed/width1*width1);

　　　y1=System.Math.Abs(speed-speed/height1*height1);

　　}

　　if(speed==6*width1)

　　speed=0;

　　picture1.Location=new System.Drawing.Point(x1,y1);

　}

　private void StopScreenSaver() file://停止屏幕保護程序運行

　{

　　System.Windows.Forms.Cursor.Show();

　　timerSaver.Enabled=false;

　　Application.Exit();

　}


　private void screen_MouseMove(object sender, System.Windows.Forms.MouseEventArgs e)　
　file://鼠標移動事件

　{

　　if(ixStart==0 && iyStart==0)

　　{

　　　ixStart=e.X;

　　　iyStart=e.Y;

　　　return;

　　}

　　else if(e.X!=ixStart||e.Y!=iyStart)

　　StopScreenSaver();

　}

　private void screen_MouseDown(object sender, System.Windows.Forms.MouseEventArgs e)
　file://鼠標按下事件

　{

　　StopScreenSaver(); file://停止運行屏幕保護程序

　}

　private void screen_KeyDown(object sender, System.Windows.Forms.KeyEventArgs e)　
　file://鍵盤按下事件

　{

　　StopScreenSaver(); file://停止運行屏幕保護程序

　}

}

}


　　最後運行該程序，把screen_saver.exe改為screen_saver.scr，拷入Windows系統目錄中，這樣就可以運行該屏幕保護程序。

    上一頁:C# 2.0 Specification(匿名方法)(二)
    下一頁:如何在C#中使用 Win32和其他庫

關於C語言
C#發現之旅-高性能ASP.NET樹狀列表控件(下)(2)

在這個模板中首先接受了一個名為Level的參數，該參數表示
C#編程中使用設計模式中的原型模式的實例講解

一、引言在軟件系統中，當創建一個類的實例的過程很昂貴或很復
C#中ZipHelper 壓縮和解壓幫助類

關於本文檔的說明　　本文檔基於ICSharpCode.Sh
FFmpeg Windows 開發環境簡單搭建 教程

 FFmpeg 是一個優秀的程序庫，開
Office 2000風格的停泊、智能型菜單的實現

譯者注： 由於原文作者所提
經典算法研究系列：一之續、A*，Dijkstra，雙向BFS算法性能比較及A*算法的應用

 本文，即以演示圖的形式，比較它們各自的尋路
相關文章

    運用El表達式截取字符串/獲取list的長度實例
    Spring 中 @Service 和 @Resource 注解的區別
    vc++-win32 sdk如何對 listbox畫表格
    C++開發之ostringstream、istringstream、stringstream用法淺析
    [示例] 用代碼設置 ListView 顏色 （只適用 Win 平台，無需修改官方源碼），listviewwin
    [修正] Firemonkey SpeedButton 鼠標移開按鈕後 IsPressed 為 False 的問題，wpfbuttonispressed
    bzoj 1143: [CTSC2008]祭祀river / 2718: [Violet 4]畢業旅行，bzojctsc2008
    SVG格式轉Visio的vsd格式方法，附帶C#動態調用Office的Com組件方法，
    [轉]webapi部署在IIS7.5報404的解決方案，webapiiis7.5
    Asp.net MVC 發布到IIS6，mvciis6

閱讀排行榜
c語言：猴子吃桃問題
Java編程比C編程好嗎？《精通Unix下C語言與項目實踐》讀書筆記（15）
OC：OC中的集合類-NSArray（一）
“chaos”的算法--之快速排序
問題四十七: 有等式[※×(※3+※)]2=8※※9，其中※處為1個數字，滴上了墨水無法辨認
c#中模擬鍵盤（1）
如何在C#中播放AVI短片並使背景透明
使用Sharpen java to C#把java項目轉化為C#項目(2)
C#發現之旅第二講 C#－XSLT開發(5)
C#下WinForm編程：登錄窗體的設計
ASP.NET總結C#中7種獲取當前路徑的方法
熱門圖文
在J2ME中實現游戲功能選擇界面(附源代碼)
php過濾html標記屬性類用法實例，標記實例
php 判斷網頁是否是utf8編碼的方法
PHP環境搭建的詳細步驟
你知道C#各種排序的編寫及性能嗎（1）
如何獲得CPU使用率
J2EE配置指南
UVa145 Gondwanaland Telecom
欄目導航
C
C++
VC
VC.net
關於C語言
Copyright © 程式師世界 All Rights Reserved
