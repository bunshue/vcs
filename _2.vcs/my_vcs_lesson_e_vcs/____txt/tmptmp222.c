
//自定義異常處理類
using System;
using System.Diagnostics;

namespace MyAppException
{
　/// ＜summary＞
　/// 從系統異常類ApplicationException繼承的應用程序異常處理類。


　/// 自動將異常內容記錄到Windows NT/2000的應用程序日志
　/// ＜/summary＞
　public class AppException:System.ApplicationException
　{
　　public AppException()
　　{
　　　if (ApplicationConfiguration.EventLogEnabled)LogEvent("出現一個未知錯誤。");
　　}

　public AppException(string message)
　{
　　LogEvent(message);
　}

　public AppException(string message,Exception innerException)
　{
　　LogEvent(message);
　　if (innerException != null)
　　{
　　　LogEvent(innerException.Message);
　　}
　}

　//日志記錄類
　using System;
　using System.Configuration;
　using System.Diagnostics;
　using System.IO;
　using System.Text;
　using System.Threading;

　namespace MyEventLog
　{
　　/// ＜summary＞
　　/// 事件日志記錄類，提供事件日志記錄支持
　　/// ＜remarks＞
　　/// 定義了4個日志記錄方法 (error, warning, info, trace)
　　/// ＜/remarks＞
　　/// ＜/summary＞
　　public class ApplicationLog
　　{
　　　/// ＜summary＞
　　　/// 將錯誤信息記錄到Win2000/NT事件日志中
　　　/// ＜param name="message"＞需要記錄的文本信息＜/param＞
　　　/// ＜/summary＞
　　　public static void WriteError(String message)
　　　{
　　　　WriteLog(TraceLevel.Error, message);
　　　}

　　　/// ＜summary＞
　　　/// 將警告信息記錄到Win2000/NT事件日志中
　　　/// ＜param name="message"＞需要記錄的文本信息＜/param＞
　　　/// ＜/summary＞
　　　public static void WriteWarning(String message)
　　　{
　　　　WriteLog(TraceLevel.Warning, message);　　
　　　}

　　　/// ＜summary＞
　　　/// 將提示信息記錄到Win2000/NT事件日志中
　　　/// ＜param name="message"＞需要記錄的文本信息＜/param＞
　　　/// ＜/summary＞
　　　public static void WriteInfo(String message)
　　　{
　　　　WriteLog(TraceLevel.Info, message);
　　　}
　　　/// ＜summary＞
　　　/// 將跟蹤信息記錄到Win2000/NT事件日志中
　　　/// ＜param name="message"＞需要記錄的文本信息＜/param＞
　　　/// ＜/summary＞
　　　public static void WriteTrace(String message)
　　　{
　　　　WriteLog(TraceLevel.Verbose, message);
　　　}

　　　/// ＜summary＞
　　　/// 格式化記錄到事件日志的文本信息格式
　　　/// ＜param name="ex"＞需要格式化的異常對象＜/param＞
　　　/// ＜param name="catchInfo"＞異常信息標題字符串.＜/param＞
　　　/// ＜retvalue＞
　　　/// ＜para＞格式後的異常信息字符串，包括異常內容和跟蹤堆棧.＜/para＞
　　　/// ＜/retvalue＞
　　　/// ＜/summary＞
　　　public static String FormatException(Exception ex, String catchInfo)
　　　{
　　　　StringBuilder strBuilder = new StringBuilder();
　　　　if (catchInfo != String.Empty)
　　　　{
　　　　　strBuilder.Append(catchInfo).Append("\r\n");
　　　　}
　　　　strBuilder.Append(ex.Message).Append("\r\n").Append(ex.StackTrace);
　　　　return strBuilder.ToString();
　　　}

　　　/// ＜summary＞
　　　/// 實際事件日志寫入方法
　　　/// ＜param name="level"＞要記錄信息的級別（error,warning,info,trace).＜/param＞
　　　/// ＜param name="messageText"＞要記錄的文本.＜/param＞
　　　/// ＜/summary＞
　　　private static void WriteLog(TraceLevel level, String messageText)
　　　{
　　　　try
　　　　{
　　　　　EventLogEntryType LogEntryType;
　　　　　switch (level)
　　　　　{
　　　　　　case TraceLevel.Error:
　　　　　　　LogEntryType = EventLogEntryType.Error;
　　　　　　　break;
　　　　　　case TraceLevel.Warning:
　　　　　　　LogEntryType = EventLogEntryType.Warning;
　　　　　　　break;
　　　　　　case TraceLevel.Info:
　　　　　　　LogEntryType = EventLogEntryType.Information;
　　　　　　　break;
　　　　　　case TraceLevel.Verbose:
　　　　　　　LogEntryType = EventLogEntryType.SuccessAudit;
　　　　　　　break;
　　　　　　default:
　　　　　　　LogEntryType = EventLogEntryType.SuccessAudit;
　　　　　　　break;
　　　　　}

　　　　　EventLog eventLog = new EventLog("Application", ApplicationConfiguration.EventLogMachineName, ApplicationConfiguration.EventLogSourceName );
　　　　　//寫入事件日志
　　　　　eventLog.WriteEntry(messageText, LogEntryType);

　　　　}
　　　catch {} //忽略任何異常
　　}
　} //class ApplicationLog
}











