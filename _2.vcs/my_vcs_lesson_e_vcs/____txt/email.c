//加入命名空間
using System.Net.Mail;

//加入私有成員
private MailMessage msg;      //用於構造郵件屬性和方法
private Attachment att;       //用於構造郵件附件屬性和方法

public Form1()
{
    InitializeComponent();
    msg = new MailMessage();  //實例化
}

//點擊"發送郵件"按鈕
private void button1_Click(object sender, EventArgs e)
{
    try
    {
        //To郵件收信人地址屬性 僅僅讀屬性不能賦值
        msg.To.Add(textBox1.Text);
        //From郵件發件人地址屬性
        msg.From = new MailAddress(textBox2.Text);
        //Subject郵件主題屬性
        msg.Subject = textBox3.Text;
        msg.SubjectEncoding = Encoding.Default;
        //Body設置郵件內容屬性
        msg.Body = richTextBox1.Text;
        msg.BodyEncoding = Encoding.Default;

        //設置郵件的優先級Priority屬性
        if (radioButton1.Checked)
            msg.Priority = MailPriority.High;
        else if (radioButton2.Checked)
            msg.Priority = MailPriority.Low;
        else if (radioButton3.Checked)
            msg.Priority = MailPriority.Normal;
        else
            msg.Priority = MailPriority.Normal;

        //發送郵件
        SmtpClient client = new SmtpClient();
        //郵件server設置smtpport 默認25
        client.Host = "smtp.163.com";           
        client.Port = 25;                       
        //郵件發送方式 通過網絡發送到SMTPserver
        client.DeliveryMethod = System.Net.Mail.SmtpDeliveryMethod.Network;
        //憑證 發件人登錄郵箱的username和password
        client.Credentials = new System.Net.NetworkCredential("1520161xxxx", "19911203xxxx");
        client.Send(msg);
        MessageBox.Show("郵件發送成功！", "提示", MessageBoxButtons.OK, MessageBoxIcon.Information);  
    }
    catch (Exception m) //異常處理
    {
        MessageBox.Show(m.Message);
    }
}

//點擊"加入附件"按鈕
private void button2_Click(object sender, EventArgs e)
{
    OpenFileDialog openFileDialog = new OpenFileDialog();
    openFileDialog.CheckFileExists = true;  //不存在文件名稱顯示警告
    openFileDialog.ValidateNames = true;    //值接受Win32文件
    openFileDialog.Multiselect = false;     //不同意多選文件
    openFileDialog.Filter = "全部文件(*.*)|*.*";
            
    //加入附件 現僅支持加入一個附件
    if (openFileDialog.ShowDialog() == DialogResult.OK)
    {
        richTextBox1.Text = openFileDialog.FileName;
        att = new Attachment(openFileDialog.FileName);
        msg.Attachments.Add(att);
    }
}

//點擊"刪除附件"按鈕
private void button3_Click(object sender, EventArgs e)
{
    msg.Attachments.Clear();
}



