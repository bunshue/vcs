// 源文件头信息：
// <copyright file="Email.cs,EmailHelp.cs">
// Copyright(c)2014-2034 Kencery.All rights reserved.
// 个人博客：http://www.cnblogs.com/hanyinglong
// 创建人：韩迎龙(kencery)
// 创建时间：2015-8-18
// </copyright>

using System;
using System.Net;
using System.Net.Mail;
using System.Text;

namespace KenceryCommonMethod
{
	
	
	
	
    /// <summary>
    /// 功能：实现邮件发送,分装发送邮件的调用方法
    /// </summary>
    /// <auther>
    ///     <name>Kencery</name>
    ///     <date>2015-8-18</date>
    /// </auther>
    public class Email
    {
        #region  --------------------字段--------------------

        private string _serviceType = "SMTP";
        private string _host;

        #endregion

        #region  --------------------属性--------------------

        /// <summary>
        /// 发送者邮箱
        /// </summary>
        public string From { get; set; }

        /// <summary>
        /// 接收者邮箱列表
        /// </summary>
        public string[] To { get; set; }

        /// <summary>
        /// 抄送者邮箱列表
        /// </summary>
        public string[] Cc { get; set; }

        /// <summary>
        /// 秘抄者邮箱列表
        /// </summary>
        public string[] Bcc { get; set; }

        /// <summary>
        /// 邮件主题
        /// </summary>
        public string Subject { get; set; }

        /// <summary>
        /// 邮件内容
        /// </summary>
        public string Body { get; set; }

        /// <summary>
        /// 是否是HTML格式
        /// </summary>
        public bool IsBodyHtml { get; set; }

        /// <summary>
        /// 附件列表
        /// </summary>
        public string[] Attachments { get; set; }

        /// <summary>
        /// 邮箱服务类型(Pop3,SMTP,IMAP,MAIL等)，默认为SMTP
        /// </summary>
        public string ServiceType
        {
            get { return _serviceType; }
            set { _serviceType = value; }
        }

        /// <summary>
        /// 邮箱服务器，如果没有定义邮箱服务器，则根据serviceType和Sender组成邮箱服务器
        /// </summary>
        public string Host
        {
            get
            {
                return string.IsNullOrEmpty(_host)
                    ? (this.ServiceType + "." +
                       Sender.Split("@".ToCharArray(), StringSplitOptions.RemoveEmptyEntries)[1])
                    : _host;
            }
            set { _host = value; }
        }

        /// <summary>
        /// 邮箱账号(默认为发送者邮箱的账号)
        /// </summary>
        public string UserName { get; set; }

        /// <summary>
        /// 邮箱密码(默认为发送者邮箱的密码)，默认格式GB2312
        /// </summary>
        public string Password { get; set; }

        /// <summary>
        /// 邮箱优先级
        /// </summary>
        public MailPriority MailPriority { get; set; }

        /// <summary>
        ///  邮件正文编码格式
        /// </summary>
        public Encoding Encoding { get; set; }

        #endregion

        #region  ------------------调用方法------------------

        /// <summary>
        /// 构造参数，发送邮件，使用方法备注：公开方法中调用
        /// </summary>
        public void Send()
        {
            var mailMessage = new MailMessage();

            //读取To  接收者邮箱列表
            if (this.To != null && this.To.Length > 0)
            {
                foreach (string to in this.To)
                {
                    if (string.IsNullOrEmpty(to)) continue;
                    try
                    {
                        mailMessage.To.Add(new MailAddress(to.Trim()));
                    }
                    catch (Exception ex)
                    {
                        throw new Exception(ex.Message);
                    }
                }
            }
            //读取Cc  抄送者邮件地址
            if (this.Cc != null && this.Cc.Length > 0)
            {
                foreach (var cc in this.Cc)
                {
                    if (string.IsNullOrEmpty(cc)) continue;
                    try
                    {
                        mailMessage.CC.Add(new MailAddress(cc.Trim()));
                    }
                    catch (Exception ex)
                    {
                        throw new Exception(ex.Message);
                    }
                }
            }
            //读取Attachments 邮件附件
            if (this.Attachments != null && this.Attachments.Length > 0)
            {
                foreach (var attachment in this.Attachments)
                {
                    if (string.IsNullOrEmpty(attachment)) continue;
                    try
                    {
                        mailMessage.Attachments.Add(new Attachment(attachment));
                    }
                    catch (Exception ex)
                    {
                        throw new Exception(ex.Message);
                    }
                }
            }
            //读取Bcc 秘抄人地址
            if (this.Bcc != null && this.Bcc.Length > 0)
            {
                foreach (var bcc in this.Bcc)
                {
                    if (string.IsNullOrEmpty(bcc)) continue;
                    try
                    {
                        mailMessage.Bcc.Add(new MailAddress(bcc.Trim()));
                    }
                    catch (Exception ex)
                    {
                        throw new Exception(ex.Message);
                    }
                }
            }
            //读取From 发送人地址
            try
            {
                mailMessage.From = new MailAddress(this.From);
            }
            catch (Exception ex)
            {
                throw new Exception(ex.Message);
            }

            //邮件标题
            Encoding encoding = Encoding.GetEncoding("GB2312");
            mailMessage.Subject = string.Format("?={0}?B?{1}?=", encoding.HeaderName,
                Convert.ToBase64String(encoding.GetBytes(this.Subject), Base64FormattingOptions.None));
            //邮件正文是否为HTML格式
            mailMessage.IsBodyHtml = this.IsBodyHtml;
            //邮件正文
            mailMessage.Body = this.Body;
            mailMessage.BodyEncoding = this.Encoding;
            //邮件优先级
            mailMessage.Priority = this.MailPriority;

            //发送邮件代码实现
            var smtpClient = new SmtpClient
            {
                Host = this.Host,
                Credentials = new NetworkCredential(this.UserName, this.Password)
            };
            //认证
            try
            {
                smtpClient.Send(mailMessage);
            }
            catch (Exception ex)
            {
                throw new Exception(ex.Message);
            }
        }

        #endregion
    }

    /// <summary>
    ///邮件发送接口调用：bool isTrue=EmailInfo.SendEmail(参数,........);   参数解释参考方法
    /// <auther>
    ///     <name>Kencery</name>
    ///     <date>2015-8-18</date>
    /// </auther>
    /// </summary>
    public static class EmailInfo
    {
        /// <summary>
        /// 邮件发送方法，传递参数(使用中如出现问题，请调试)
        /// </summary>
        /// <param name="from">发送者邮箱名称(从配置文件中读取，比如：934532778@qq.com)(必填项)</param>
        /// <param name="to">接收者邮箱列表，可以传递多个，使用string[]表示(从配置文件中读取)(必填项)</param>
        /// <param name="cc">抄送者邮箱列表，可以传递多个，使用string[]表示(从配置文件中读取)</param>
        /// <param name="bcc">秘抄者邮箱列表，可以传递多个，使用string[]表示(从配置文件中读取)</param>
        /// <param name="subject">邮件主题，构造(必填项)</param>
        /// <param name="body">邮件内容，构造发送的邮件内容，可以发送网页(必填项)</param>
        /// <param name="isBodyHtml">是否是HTML格式，true为是，false为否</param>
        /// <param name="attachments">邮箱附件，可以传递多个，使用string[]表示(从配置文件中读取)，可空</param>
        /// <param name="host">邮箱服务器(从配置文件中读取，如：smtp@qq.com)(必填项)</param>
        /// <param name="password">邮箱密码(从配置文件中读取，from邮箱的密码)(必填项)</param>
        /// <returns>邮件发送成功，返回true,否则返回false</returns>
        public static bool SendEmail(string from, string[] to, string[] cc, string[] bcc, string subject, string body,
            bool isBodyHtml, string[] attachments, string host, string password)
        {
            //邮箱发送不满足，限制这些参数必须传递
            if (from == "" || to.Length <= 0 || subject == "" || body == "" || host == "" || password == "")
            {
                return false;
            }

            var emil = new Email
            {
                From = @from,
                To = to,
                Cc = cc,
                Bcc = bcc,
                Subject = subject,
                Body = body,
                IsBodyHtml = isBodyHtml,
                Attachments = attachments,
                Host = host,
                Password = password
            };
            try
            {
                emil.Send();
                return true;
            }
            catch (Exception ex)
            {
                throw new Exception(ex.Message);
            }
        }
    }
}



//Smtp郵件發送系統公用代碼整理—總結，smtp郵件發送系統

  1 // 源文件頭信息：
  2 // <copyright file="Email.cs,EmailHelp.cs">
  3 // Copyright(c)2014-2034 Kencery.All rights reserved.
  4 // 個人博客：http://www.cnblogs.com/hanyinglong
  5 // 創建人：韓迎龍(kencery)
  6 // 創建時間：2015-8-18
  7 // </copyright>
  8 
  9 using System;
 10 using System.Net;
 11 using System.Net.Mail;
 12 using System.Text;
 13 
 14 namespace KenceryCommonMethod
 15 {
 16     /// <summary>
 17     /// 功能：實現郵件發送,分裝發送郵件的調用方法
 18     /// </summary>
 19     /// <auther>
 20     ///     <name>Kencery</name>
 21     ///     <date>2015-8-18</date>
 22     /// </auther>
 23     public class Email
 24     {
 25         #region  --------------------字段--------------------
 26 
 27         private string _serviceType = "SMTP";
 28         private string _host;
 29 
 30         #endregion
 31 
 32         #region  --------------------屬性--------------------
 33 
 34         /// <summary>
 35         /// 發送者郵箱
 36         /// </summary>
 37         public string From { get; set; }
 38 
 39         /// <summary>
 40         /// 接收者郵箱列表
 41         /// </summary>
 42         public string[] To { get; set; }
 43 
 44         /// <summary>
 45         /// 抄送者郵箱列表
 46         /// </summary>
 47         public string[] Cc { get; set; }
 48 
 49         /// <summary>
 50         /// 秘抄者郵箱列表
 51         /// </summary>
 52         public string[] Bcc { get; set; }
 53 
 54         /// <summary>
 55         /// 郵件主題
 56         /// </summary>
 57         public string Subject { get; set; }
 58 
 59         /// <summary>
 60         /// 郵件內容
 61         /// </summary>
 62         public string Body { get; set; }
 63 
 64         /// <summary>
 65         /// 是否是HTML格式
 66         /// </summary>
 67         public bool IsBodyHtml { get; set; }
 68 
 69         /// <summary>
 70         /// 附件列表
 71         /// </summary>
 72         public string[] Attachments { get; set; }
 73 
 74         /// <summary>
 75         /// 郵箱服務類型(Pop3,SMTP,IMAP,MAIL等)，默認為SMTP
 76         /// </summary>
 77         public string ServiceType
 78         {
 79             get { return _serviceType; }
 80             set { _serviceType = value; }
 81         }
 82 
 83         /// <summary>
 84         /// 郵箱服務器，如果沒有定義郵箱服務器，則根據serviceType和Sender組成郵箱服務器
 85         /// </summary>
 86         public string Host
 87         {
 88             get
 89             {
 90                 return string.IsNullOrEmpty(_host)
 91                     ? (this.ServiceType + "." +
 92                        Sender.Split("@".ToCharArray(), StringSplitOptions.RemoveEmptyEntries)[1])
 93                     : _host;
 94             }
 95             set { _host = value; }
 96         }
 97 
 98         /// <summary>
 99         /// 郵箱賬號(默認為發送者郵箱的賬號)
100         /// </summary>
101         public string UserName { get; set; }
102 
103         /// <summary>
104         /// 郵箱密碼(默認為發送者郵箱的密碼)，默認格式GB2312
105         /// </summary>
106         public string Password { get; set; }
107 
108         /// <summary>
109         /// 郵箱優先級
110         /// </summary>
111         public MailPriority MailPriority { get; set; }
112 
113         /// <summary>
114         ///  郵件正文編碼格式
115         /// </summary>
116         public Encoding Encoding { get; set; }
117 
118         #endregion
119 
120         #region  ------------------調用方法------------------
121 
122         /// <summary>
123         /// 構造參數，發送郵件，使用方法備注：公開方法中調用
124         /// </summary>
125         public void Send()
126         {
127             var mailMessage = new MailMessage();
128 
129             //讀取To  接收者郵箱列表
130             if (this.To != null && this.To.Length > 0)
131             {
132                 foreach (string to in this.To)
133                 {
134                     if (string.IsNullOrEmpty(to)) continue;
135                     try
136                     {
137                         mailMessage.To.Add(new MailAddress(to.Trim()));
138                     }
139                     catch (Exception ex)
140                     {
141                         throw new Exception(ex.Message);
142                     }
143                 }
144             }
145             //讀取Cc  抄送者郵件地址
146             if (this.Cc != null && this.Cc.Length > 0)
147             {
148                 foreach (var cc in this.Cc)
149                 {
150                     if (string.IsNullOrEmpty(cc)) continue;
151                     try
152                     {
153                         mailMessage.CC.Add(new MailAddress(cc.Trim()));
154                     }
155                     catch (Exception ex)
156                     {
157                         throw new Exception(ex.Message);
158                     }
159                 }
160             }
161             //讀取Attachments 郵件附件
162             if (this.Attachments != null && this.Attachments.Length > 0)
163             {
164                 foreach (var attachment in this.Attachments)
165                 {
166                     if (string.IsNullOrEmpty(attachment)) continue;
167                     try
168                     {
169                         mailMessage.Attachments.Add(new Attachment(attachment));
170                     }
171                     catch (Exception ex)
172                     {
173                         throw new Exception(ex.Message);
174                     }
175                 }
176             }
177             //讀取Bcc 秘抄人地址
178             if (this.Bcc != null && this.Bcc.Length > 0)
179             {
180                 foreach (var bcc in this.Bcc)
181                 {
182                     if (string.IsNullOrEmpty(bcc)) continue;
183                     try
184                     {
185                         mailMessage.Bcc.Add(new MailAddress(bcc.Trim()));
186                     }
187                     catch (Exception ex)
188                     {
189                         throw new Exception(ex.Message);
190                     }
191                 }
192             }
193             //讀取From 發送人地址
194             try
195             {
196                 mailMessage.From = new MailAddress(this.From);
197             }
198             catch (Exception ex)
199             {
200                 throw new Exception(ex.Message);
201             }
202 
203             //郵件標題
204             Encoding encoding = Encoding.GetEncoding("GB2312");
205             mailMessage.Subject = string.Format("?={0}?B?{1}?=", encoding.HeaderName,
206                 Convert.ToBase64String(encoding.GetBytes(this.Subject), Base64FormattingOptions.None));
207             //郵件正文是否為HTML格式
208             mailMessage.IsBodyHtml = this.IsBodyHtml;
209             //郵件正文
210             mailMessage.Body = this.Body;
211             mailMessage.BodyEncoding = this.Encoding;
212             //郵件優先級
213             mailMessage.Priority = this.MailPriority;
214 
215             //發送郵件代碼實現
216             var smtpClient = new SmtpClient
217             {
218                 Host = this.Host,
219                 Credentials = new NetworkCredential(this.UserName, this.Password)
220             };
221             //認證
222             try
223             {
224                 smtpClient.Send(mailMessage);
225             }
226             catch (Exception ex)
227             {
228                 throw new Exception(ex.Message);
229             }
230         }
231 
232         #endregion
233     }
234 
235     /// <summary>
236     ///郵件發送接口調用：bool isTrue=EmailInfo.SendEmail(參數,........);   參數解釋參考方法
237     /// <auther>
238     ///     <name>Kencery</name>
239     ///     <date>2015-8-18</date>
240     /// </auther>
241     /// </summary>
242     public static class EmailInfo
243     {
244         /// <summary>
245         /// 郵件發送方法，傳遞參數(使用中如出現問題，請調試)
246         /// </summary>
247         /// <param name="from">發送者郵箱名稱(從配置文件中讀取，比如：934532778@qq.com)(必填項)</param>
248         /// <param name="to">接收者郵箱列表，可以傳遞多個，使用string[]表示(從配置文件中讀取)(必填項)</param>
249         /// <param name="cc">抄送者郵箱列表，可以傳遞多個，使用string[]表示(從配置文件中讀取)</param>
250         /// <param name="bcc">秘抄者郵箱列表，可以傳遞多個，使用string[]表示(從配置文件中讀取)</param>
251         /// <param name="subject">郵件主題，構造(必填項)</param>
252         /// <param name="body">郵件內容，構造發送的郵件內容，可以發送網頁(必填項)</param>
253         /// <param name="isBodyHtml">是否是HTML格式，true為是，false為否</param>
254         /// <param name="attachments">郵箱附件，可以傳遞多個，使用string[]表示(從配置文件中讀取)，可空</param>
255         /// <param name="host">郵箱服務器(從配置文件中讀取，如：smtp@qq.com)(必填項)</param>
256         /// <param name="password">郵箱密碼(從配置文件中讀取，from郵箱的密碼)(必填項)</param>
257         /// <returns>郵件發送成功，返回true,否則返回false</returns>
258         public static bool SendEmail(string from, string[] to, string[] cc, string[] bcc, string subject, string body,
259             bool isBodyHtml, string[] attachments, string host, string password)
260         {
261             //郵箱發送不滿足，限制這些參數必須傳遞
262             if (from == "" || to.Length <= 0 || subject == "" || body == "" || host == "" || password == "")
263             {
264                 return false;
265             }
266 
267             var emil = new Email
268             {
269                 From = @from,
270                 To = to,
271                 Cc = cc,
272                 Bcc = bcc,
273                 Subject = subject,
274                 Body = body,
275                 IsBodyHtml = isBodyHtml,
276                 Attachments = attachments,
277                 Host = host,
278                 Password = password
279             };
280             try
281             {
282                 emil.Send();
283                 return true;
284             }
285             catch (Exception ex)
286             {
287                 throw new Exception(ex.Message);
288             }
289         }
290     }
291 }

