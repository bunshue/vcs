# Keil uVision project CS8963_BLDC.uvproj, settings and files
target Target 1 (MCS-51)
  device: DR80390 Digital Core Design
  cpu: IRAM(0-0xFF) CLOCK(50000000) MOD_CONT MODDP2
  output: CS8963_BLDC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\CS8963_Libraries\inc
  group Source Group 1
    ../../CS8963_Libraries/src/: CS8963_Config.c CS8963_Function.c CS8963_Initial.c CS8963_ISR.c CS8963_PWM.c CS8963_WatchDog.c CS8963_Motor_Function.c CS8963_Setup.c CS8963_ADC.c CS8963_I2C.c CS8963_Clock.c CS8963_Timer.c CS8963_UART.c CS8963_Flash.c CS8963_DAC.c CS8963_Test.c CS8963_MysonLink.c CS8963_Sensorless.c CS8963_PCA.c mdu80390.a51
    ../src/: CS8963_BLDC.c
